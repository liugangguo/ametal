# Keil uVision project demo_am824zb_bootloader.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC824M201JDH20 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x00008000) IRAM(0x10000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demo_am824zb_bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\..\components\service\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\soc\nxp\lpc824;..\..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\..\components\util\include;..\..\..\..\bsp_common\include;..\..\..\..\..\arch\arm\include;..\..\..\..\bsp_common\include;..\..\..\..\..\interface;..\..\..\..\..\soc\nxp\drivers\include\acmp;..\..\..\..\..\soc\nxp\drivers\include\adc;..\..\..\..\..\soc\nxp\drivers\include\clk;..\..\..\..\..\soc\nxp\drivers\include\crc;..\..\..\..\..\soc\nxp\drivers\include\dma;..\..\..\..\..\soc\nxp\drivers\include\fmc;..\..\..\..\..\soc\nxp\drivers\include\gpio;..\..\..\..\..\soc\nxp\drivers\include\i2c;..\..\..\..\..\soc\nxp\drivers\include\iap;..\..\..\..\..\soc\nxp\drivers\include\inmux;..\..\..\..\..\soc\nxp\drivers\include\iocon;..\..\..\..\..\soc\nxp\drivers\include\mrt;..\..\..\..\..\soc\nxp\drivers\include\pint;..\..\..\..\..\soc\nxp\drivers\include\pmu;..\..\..\..\..\soc\nxp\drivers\include\rit;..\..\..\..\..\soc\nxp\drivers\include\rtc;..\..\..\..\..\soc\nxp\drivers\include\sct;..\..\..\..\..\soc\nxp\drivers\include\spi;..\..\..\..\..\soc\nxp\drivers\include\swm;..\..\..\..\..\soc\nxp\drivers\include\syscon;..\..\..\..\..\soc\nxp\drivers\include\timer;..\..\..\..\..\soc\nxp\drivers\include\usart;..\..\..\..\..\soc\nxp\drivers\include\utick;..\..\..\..\..\soc\nxp\drivers\include\wkt;..\..\..\..\..\soc\nxp\drivers\include\wwdt;..\..\..\..\..\examples\board\am824zb;..\..\..\..\..\examples\board\am824_core;..\..\..\..\..\examples\soc\nxp;..\..\..\..\..\examples\std;..\..\..\..\..\examples\components;..\..\..\..\..\components\bootloader\include\core;..\..\..\..\..\soc\nxp\lpc824\bootloader\include;..\user_config\am_bootconf_usrcfg
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\demo_am824zb_bootloader.sct
  group bsp_common
    ../../../../bsp_common/source/: am_assert.c am_bsp_armlib.c am_bsp_microlib.c am_bsp_system_heap.c am_bsp_isr_defer_pendsv.c am_bsp_delay_timer.c
  group arm
    ../../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../../components/drivers/source/digitron_key/: am_zlg72128.c am_zlg72128_std.c
    ../../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../../components/drivers/source/zlg600/: am_zlg600.c
  group libc
    ../../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_category_input.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c am_dac.c
  group util
    ../../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../../soc/nxp/drivers/source/adc/: am_lpc82x_adc_dma.c am_lpc82x_adc_int.c
    ../../../../../soc/nxp/drivers/source/clk/: am_lpc82x_clk.c
    ../../../../../soc/nxp/drivers/source/dma/: am_lpc82x_dma.c
    ../../../../../soc/nxp/drivers/source/gpio/: am_lpc82x_gpio.c
    ../../../../../soc/nxp/drivers/source/spi/: am_lpc82x_spi_dma.c am_lpc_spi_int.c
    ../../../../../soc/nxp/drivers/source/adc/hw/: amhw_lpc82x_adc.c
    ../../../../../soc/nxp/drivers/source/clk/hw/: amhw_lpc82x_clk.c
    ../../../../../soc/nxp/drivers/source/iap/hw/: amhw_lpc82x_iap.c
    ../../../../../soc/nxp/drivers/source/iocon/hw/: amhw_lpc82x_iocon.c
    ../../../../../soc/nxp/drivers/source/pint/hw/: amhw_lpc82x_pint.c
    ../../../../../soc/nxp/drivers/source/swm/hw/: amhw_lpc82x_swm.c
    ../../../../../soc/nxp/drivers/source/crc/: am_lpc_crc.c
    ../../../../../soc/nxp/drivers/source/i2c/: am_lpc_i2c.c
    ../../../../../soc/nxp/drivers/source/mrt/: am_lpc_mrt.c
    ../../../../../soc/nxp/drivers/source/sct/: am_lpc_sct.c am_lpc_sct_cap.c am_lpc_sct_pwm.c am_lpc_sct_timing.c
    ../../../../../soc/nxp/drivers/source/usart/: am_lpc_usart.c
    ../../../../../soc/nxp/drivers/source/wkt/: am_lpc_wkt.c
    ../../../../../soc/nxp/drivers/source/wwdt/: am_lpc_wwdt.c
    ../../../../../soc/nxp/drivers/source/crc/hw/: amhw_lpc_crc.c
    ../../../../../soc/nxp/drivers/source/sct/hw/: amhw_lpc_sct.c
    ../../../../../soc/nxp/drivers/source/usart/hw/: amhw_lpc_usart.c
    ../../../../../soc/nxp/lpc824/: lpc82x_sdk_version.c
    ../../../../../soc/nxp/drivers/source/pmu/hw/: amhw_lpc82x_pmu.c
  group examples_board
    ../../../../../examples/board/am824_core/acmp/: demo_am824_core_hw_acmp_int.c demo_am824_core_hw_acmp_lad.c demo_am824_core_hw_acmp_poll.c
    ../../../../../examples/board/am824_core/buzzer/: demo_am824_core_std_buzzer.c
    ../../../../../examples/board/am824_core/crc/: demo_am824_core_hw_crc.c demo_am824_core_std_crc.c
    ../../../../../examples/board/am824_core/dma/: demo_am824_core_drv_dma_hwtrigger_burst.c demo_am824_core_drv_dma_m2m.c demo_am824_core_drv_dma_ping_pong.c
    ../../../../../examples/board/am824_core/flash_ctrl/: demo_am824_core_hw_flash_ctrl.c
    ../../../../../examples/board/am824_core/gpio/: demo_am824_core_hw_gpio.c demo_am824_core_hw_gpio_int.c demo_am824_core_hw_gpio_pmatch.c demo_am824_core_std_gpio.c demo_am824_core_std_gpio_int.c demo_am824_core_std_gpio_key.c
    ../../../../../examples/board/am824_core/i2c/: demo_am824_core_hw_i2c_master_dma.c demo_am824_core_hw_i2c_master_poll.c demo_am824_core_hw_i2c_slave_dma.c demo_am824_core_hw_i2c_slave_int.c demo_am824_core_hw_i2c_slave_poll.c demo_am824_core_std_i2c_lm75.c demo_am824_core_std_i2c_master_async.c demo_am824_core_std_i2c_master_sync.c
    ../../../../../examples/board/am824_core/iap/: demo_am824_core_hw_iap.c
    ../../../../../examples/board/am824_core/input_event/: demo_am824_core_std_key_input_event.c
    ../../../../../examples/board/am824_core/led/: demo_am824_core_std_led.c
    ../../../../../examples/board/am824_core/miniport_board/: demo_am824_core_miniport_digitron.c demo_am824_core_miniport_hc595_digitron.c demo_am824_core_miniport_hc595_digitron_key.c demo_am824_core_miniport_hc595_digitron_temp.c demo_am824_core_miniport_hc595_led.c demo_am824_core_miniport_key.c demo_am824_core_miniport_key_digitron.c demo_am824_core_miniport_led.c demo_am824_core_miniport_zlg72128.c
    ../../../../../examples/board/am824_core/mrt/: demo_am824_core_hw_mrt.c demo_am824_core_std_mrt_timer.c
    ../../../../../examples/board/am824_core/pll/: demo_am824_core_hw_pll.c
    ../../../../../examples/board/am824_core/pmu/: demo_am824_core_hw_pmu_deeppowerdown.c demo_am824_core_hw_pmu_deepsleep.c demo_am824_core_hw_pmu_powerdown.c demo_am824_core_hw_pmu_sleep.c
    ../../../../../examples/board/am824_core/sct/: demo_am824_core_drv_sct_timing_pwm.c demo_am824_core_hw_sct_1_32bit_pwm.c demo_am824_core_hw_sct_1_32bit_timing.c demo_am824_core_hw_sct_2_16bit_pwm.c demo_am824_core_hw_sct_2_16bit_timing.c demo_am824_core_hw_sct_cap.c demo_am824_core_hw_sct_multi_states.c demo_am824_core_std_sct_cap.c demo_am824_core_std_sct_pwm.c demo_am824_core_std_sct_timer.c
    ../../../../../examples/board/am824_core/spi/: demo_am824_core_hw_spi_master.c demo_am824_core_hw_spi_slave.c demo_am824_core_hw_spi_slave_dma.c demo_am824_core_std_spi_flash_dma.c demo_am824_core_std_spi_flash_int.c demo_am824_core_std_spi_master_dma.c demo_am824_core_std_spi_master_int.c
    ../../../../../examples/board/am824_core/syscon/: demo_am824_core_hw_bod.c demo_am824_core_hw_clkout.c
    ../../../../../examples/board/am824_core/systick/: demo_am824_core_std_delay.c demo_am824_core_std_systick_timer.c
    ../../../../../examples/board/am824_core/usart/: demo_am824_core_hw_usart_autobaud.c demo_am824_core_hw_usart_poll.c demo_am824_core_hw_usart_rx_dma.c demo_am824_core_hw_usart_tx_dma.c demo_am824_core_std_usart_flowctrl.c demo_am824_core_std_usart_poll.c demo_am824_core_std_usart_rngbuf.c
    ../../../../../examples/board/am824_core/wkt/: demo_am824_core_hw_wkt_deeppowerdown_wakeup.c demo_am824_core_hw_wkt_timer.c demo_am824_core_std_wkt_timer.c
    ../../../../../examples/board/am824_core/wwdt/: demo_am824_core_hw_wwdt.c demo_am824_core_std_wwdt.c
    ../../../../../examples/board/am824zb/zigbee/: demo_am824zb_std_zm516x.c demo_am824zb_std_zm516x_baudrate.c demo_am824zb_std_zm516x_gpio.c demo_am824zb_std_zm516x_key_led.c demo_am824zb_std_zm516x_network.c demo_am824zb_std_zm516x_search.c
    ../../../../../examples/board/am824zb/adc/: demo_am824zb_hw_adc_dma.c demo_am824zb_hw_adc_thcmp.c demo_am824zb_std_adc_dma_int.c demo_am824zb_std_adc_dma_poll.c demo_am824zb_std_adc_int.c demo_am824zb_std_adc_ntc.c demo_am824zb_std_adc_poll.c
    ../../../../../examples/board/am824zb/bootloader/: demo_am824zb_bootloader.c
  group examples_components
    ../../../../../examples/components/service/: demo_ftl.c demo_mtd.c
    ../../../../../examples/components/drivers/: demo_ep24cxx.c demo_mx25xx.c demo_zm516x.c demo_zm516x_baudrate.c demo_zm516x_gpio.c demo_zm516x_key_led.c demo_zm516x_network.c demo_zm516x_search.c
  group examples_soc
    ../../../../../examples/soc/nxp/acmp/: demo_lpc824_hw_acmp_int.c demo_lpc824_hw_acmp_lad.c demo_lpc824_hw_acmp_poll.c
    ../../../../../examples/soc/nxp/adc/: demo_lpc_std_adc_dma_poll.c demo_lpc_std_adc_dma_int.c demo_lpc_std_adc_int.c demo_lpc_std_adc_poll.c demo_lpc824_hw_adc_dma.c demo_lpc824_hw_adc_thcmp.c
    ../../../../../examples/soc/nxp/crc/: demo_lpc_crc.c
    ../../../../../examples/soc/nxp/dma/: demo_lpc824_drv_dma_hwtrigger_burst.c demo_lpc824_drv_dma_m2m.c demo_lpc824_drv_dma_ping_pong.c
    ../../../../../examples/soc/nxp/flash_ctrl/: demo_lpc824_hw_flash_ctrl.c
    ../../../../../examples/soc/nxp/gpio/: demo_lpc_std_gpio_key.c demo_lpc824_hw_gpio.c demo_lpc824_hw_gpio_int.c demo_lpc824_hw_gpio_pmatch.c
    ../../../../../examples/soc/nxp/i2c/: demo_lpc_hw_i2c_master_poll.c demo_lpc_hw_i2c_slave_int.c demo_lpc_hw_i2c_slave_poll.c demo_lpc824_hw_i2c_master_dma.c demo_lpc824_hw_i2c_slave_dma.c
    ../../../../../examples/soc/nxp/iap/: demo_lpc824_hw_iap.c
    ../../../../../examples/soc/nxp/mrt/: demo_lpc824_hw_mrt.c
    ../../../../../examples/soc/nxp/pll/: demo_lpc824_hw_pll.c
    ../../../../../examples/soc/nxp/pmu/: demo_lpc824_hw_pmu_deeppowerdown.c demo_lpc824_hw_pmu_deepsleep.c demo_lpc824_hw_pmu_powerdown.c demo_lpc824_hw_pmu_sleep.c
    ../../../../../examples/soc/nxp/sct/: demo_am824_std_sct_cap.c demo_am824_std_sct_pwm.c demo_am824_std_sct_timer.c demo_lpc_drv_sct_timing_pwm.c demo_lpc_hw_sct_1_32bit_pwm.c demo_lpc_hw_sct_1_32bit_timing.c demo_lpc_hw_sct_2_16bit_pwm.c demo_lpc_hw_sct_2_16bit_timing.c demo_lpc_hw_sct_cap.c demo_lpc_hw_sct_multi_states.c
    ../../../../../examples/soc/nxp/spi/: demo_lpc_hw_spi_master.c demo_lpc_hw_spi_slave.c demo_lpc824_hw_spi_slave_dma.c
    ../../../../../examples/soc/nxp/syscon/: demo_lpc824_hw_bod.c demo_lpc824_hw_clkout.c
    ../../../../../examples/soc/nxp/usart/: demo_lpc_hw_usart_autobaud.c demo_lpc_hw_usart_poll.c demo_lpc824_hw_usart_rx_dma.c demo_lpc_std_usart_flowctrl.c demo_lpc824_hw_usart_tx_dma.c
    ../../../../../examples/soc/nxp/wwdt/: demo_lpc_hw_wwdt.c
    ../../../../../examples/soc/nxp/wkt/: demo_lpc_hw_wkt_timer.c demo_lpc_std_wkt_timer.c demo_lpc824_hw_wkt_deeppowerdown_wakeup.c
  group examples_std
    ../../../../../examples/std/adc/: demo_std_adc.c demo_std_adc_ntc.c
    ../../../../../examples/std/buzzer/: demo_std_buzzer.c
    ../../../../../examples/std/cap/: demo_std_timer_cap.c
    ../../../../../examples/std/crc/: demo_std_crc.c
    ../../../../../examples/std/delay/: demo_std_delay.c
    ../../../../../examples/std/digitron/: demo_std_digitron_60s_counting.c demo_std_digitron_temp.c
    ../../../../../examples/std/gpio/: demo_std_gpio_trigger.c demo_std_gpio.c
    ../../../../../examples/std/hc595/: demo_std_hc595_led.c
    ../../../../../examples/std/i2c/: demo_std_i2c_lm75.c demo_std_i2c_master_async.c demo_std_i2c_master_sync.c demo_std_i2c_slave.c demo_std_i2c_slave_subaddr.c
    ../../../../../examples/std/input/: demo_std_4key.c demo_std_key.c demo_std_key_digitron.c demo_std_key_digitron_rngbuf.c
    ../../../../../examples/std/led/: demo_std_led_water_light.c demo_std_led.c
    ../../../../../examples/std/nvram/: demo_std_nvram.c
    ../../../../../examples/std/pwm/: demo_std_timer_pwm.c
    ../../../../../examples/std/rtc/: demo_std_rtc.c
    ../../../../../examples/std/softimer/: demo_std_softimer.c
    ../../../../../examples/std/spi/: demo_std_spi_flash.c demo_std_spi_master.c demo_std_spi_slave.c
    ../../../../../examples/std/timer/: demo_std_timer_timing.c
    ../../../../../examples/std/uart/: demo_std_uart_polling.c demo_std_uart_ringbuf.c demo_std_uart_rs485.c
    ../../../../../examples/std/wdt/: demo_std_wdt.c
  group startup
    ../startup/: am_lpc82x_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_board.c am_prj_config.c am_board.h am_prj_config.h
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_arm_systick.c am_hwconf_key_gpio.c am_hwconf_led_gpio.c am_hwconf_lm75.c am_hwconf_lpc82x_adc0_dma.c am_hwconf_lpc82x_adc0_int.c am_hwconf_lpc82x_clk.c am_hwconf_lpc82x_crc.c am_hwconf_lpc82x_dma.c am_hwconf_lpc82x_gpio.c am_hwconf_lpc82x_i2c0.c am_hwconf_lpc82x_i2c1.c am_hwconf_lpc82x_i2c2.c am_hwconf_lpc82x_i2c3.c am_hwconf_lpc82x_mrt.c am_hwconf_lpc82x_sct0.c am_hwconf_lpc82x_sct0_cap.c am_hwconf_lpc82x_sct0_pwm.c am_hwconf_lpc82x_sct0_timing.c am_hwconf_lpc82x_spi0_dma.c am_hwconf_lpc82x_spi0_int.c am_hwconf_lpc82x_spi1_dma.c am_hwconf_lpc82x_spi1_int.c am_hwconf_lpc82x_usart0.c am_hwconf_lpc82x_usart1.c am_hwconf_lpc82x_usart2.c am_hwconf_lpc82x_wkt.c am_hwconf_lpc82x_wwdt.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_ds1302.c am_hwconf_ep24cxx.c am_hwconf_lpc82x_systick.c am_hwconf_pcf85063.c am_hwconf_rx8025t.c am_hwconf_zm516x.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
    ../user_config/am_bootconf_usrcfg/: am_bootconf_lpc824.c
  group bootloader
    ../../../../../soc/nxp/lpc824/bootloader/source/: am_lpc824_boot.c am_lpc824_boot_firmware_flash.c am_lpc824_boot_flash.c
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC824M201JDH20 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: as above
  output: demo_am824zb_bootloader +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\..\components\service\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\soc\nxp\lpc824;..\..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\..\components\util\include;..\..\..\..\bsp_common\include;..\..\..\..\..\arch\arm\include;..\..\..\..\bsp_common\include;..\..\..\..\..\interface;..\..\..\..\..\soc\nxp\drivers\include\acmp;..\..\..\..\..\soc\nxp\drivers\include\adc;..\..\..\..\..\soc\nxp\drivers\include\clk;..\..\..\..\..\soc\nxp\drivers\include\crc;..\..\..\..\..\soc\nxp\drivers\include\dma;..\..\..\..\..\soc\nxp\drivers\include\fmc;..\..\..\..\..\soc\nxp\drivers\include\gpio;..\..\..\..\..\soc\nxp\drivers\include\i2c;..\..\..\..\..\soc\nxp\drivers\include\iap;..\..\..\..\..\soc\nxp\drivers\include\inmux;..\..\..\..\..\soc\nxp\drivers\include\iocon;..\..\..\..\..\soc\nxp\drivers\include\mrt;..\..\..\..\..\soc\nxp\drivers\include\pint;..\..\..\..\..\soc\nxp\drivers\include\pmu;..\..\..\..\..\soc\nxp\drivers\include\rit;..\..\..\..\..\soc\nxp\drivers\include\rtc;..\..\..\..\..\soc\nxp\drivers\include\sct;..\..\..\..\..\soc\nxp\drivers\include\spi;..\..\..\..\..\soc\nxp\drivers\include\swm;..\..\..\..\..\soc\nxp\drivers\include\syscon;..\..\..\..\..\soc\nxp\drivers\include\timer;..\..\..\..\..\soc\nxp\drivers\include\usart;..\..\..\..\..\soc\nxp\drivers\include\utick;..\..\..\..\..\soc\nxp\drivers\include\wkt;..\..\..\..\..\soc\nxp\drivers\include\wwdt;..\..\..\..\..\soc\nxp\lpc824\bootloader\include;..\user_config\am_bootconf_usrcfg;..\..\..\..\..\examples\board\am824zb;..\..\..\..\..\examples\components;..\..\..\..\..\examples\soc\nxp;..\..\..\..\..\examples\std;..\..\..\..\..\components\bootloader;..\..\..\..\..\components\bootloader\include\core;..\..\..\..\..\components\bootloader\include\drivers;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool;..\..\..\..\..\components\bootloader\include\command_analyse\kboot_KinetisFlashTool\drivers
  memory RVCT4: ROM 0x0 size 0x2c00
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\demo_am824zb_bootloader.sct
